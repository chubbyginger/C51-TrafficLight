# Keil uVision project TrafficLight-button.uvproj, settings and files
target 89C52 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TrafficLight-button +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51 main.c main.h STCUART.c STCUART.h Key.c Key.h hwinit.c hwinit.h
